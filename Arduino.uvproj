# Keil uVision project Arduino.uvproj, settings and files
target Arduino (MCS-51)
  device: AT89S53 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: Arduino +hex
  c flags: Optimize=9
  c include: .\libraries;.\libraries\Arduino;.\libraries\74LS164;.\libraries\DS18B20;.\libraries\EM1190B;.\libraries\Keyscan;.\libraries\Leddisplay;.\libraries\STC15
  asm include: .\libraries;.\libraries\Arduino
  link misc: REMOVEUNUSED
  group Users
    ./: main.c
  group Arduino
    ./libraries/Arduino/: Arduino.c
  group STC15
    ./libraries/STC15/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c timer.c USART.C
  group Libraries
    ./libraries/74LS164/: 74LS164.c
    ./libraries/DS18B20/: Ds18b20.c
    ./libraries/EM1190B/: EM1190B.c
    ./libraries/Keyscan/: Keyscan.c
    ./libraries/Leddisplay/: Leddisplay.c
